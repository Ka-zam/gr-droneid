options:
  parameters:
    generate_options: qt_gui
    id: bladerf_single_trigger
    output_language: python
    title: Single DJI trigger
  states: {}

blocks:
- name: LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 750e3
    win: window.WIN_HAMMING
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay_iq
  id: variable_qtgui_range
  parameters:
    label: IQ Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '20000'
    value: '3300'
  states: {}
- name: delay_t1
  id: variable_qtgui_range
  parameters:
    label: Delay T1
    rangeType: int
    start: '1000'
    step: '1'
    stop: '5000'
    value: 1096*4
  states: {}
- name: delay_t2
  id: variable_qtgui_range
  parameters:
    label: Delay T2
    rangeType: int
    start: '1000'
    step: '1'
    stop: '4000'
    value: '2450'
  states: {state: disabled}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: FC
    start: '500'
    step: '.5'
    stop: '6000'
    value: '2405.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '63'
    value: '40'
  states: {}
- name: lo
  id: variable_qtgui_range
  parameters:
    label: LO
    start: '-15000'
    step: '1'
    stop: '15000'
    value: '-10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15360000*2
  states: {}
- name: trig_level
  id: variable_qtgui_range
  parameters:
    label: Trig level
    start: '0'
    step: '.1'
    stop: '50'
    value: '5'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_iq
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_t1
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: droneid.fc32
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/magnus/src/drone_id/samples/xad
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: lo*1e3/samp_rate*2*np.pi
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: calibrate_bladerf_single_c_0
  id: calibrate_bladerf_single_c
  parameters:
    biastee_rx: '0'
    bw: '56000000'
    ch: '0'
    external_freq: '10000000'
    external_ref: '0'
    freq: int(fc* 1000000)
    gain: gain
    gm: '0'
    samp_rate: samp_rate
    verbose: '0'
  states: {}
- name: droneid_msg_trigger_0
  id: droneid_msg_trigger
  parameters:
    threshold: '1.0'
  states: {}
- name: droneid_print_msg_0
  id: droneid_print_msg
  parameters: {}
  states: {state: disabled}
- name: droneid_save_msg_0
  id: droneid_save_msg
  parameters:
    filename: message_
  states: {state: disabled}
- name: droneid_single_trigger_0
  id: droneid_single_trigger
  parameters:
    chunk_size: '9600'
    fc: fc + lo * 1e-3
    threshold: '1.0'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: utilities.create_zc_sequence(samp_rate/decimation,4)
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: utilities.create_zc_sequence(samp_rate/decimation,6)
    type: ccc
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: window.WIN_KAISER
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.droneid import utilities
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      2414.5                       5756.5
      2429.5                       5776.5
      2444.5                       5796.5
      2459.5                       5816.5
      2474.5 (rarely)      5836.5  (rarely)

      FFT length: 1024
    note: Frequency table
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    tr_level: '0'
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: 1024*2
    srate: samp_rate
    tr_chan: '1'
    tr_level: '5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '50'
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: stream
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_delay_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', droneid_single_trigger_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_delay_0_0, '0', droneid_single_trigger_0, '0']
- [blocks_delay_0_0, '0', fosphor_glfw_sink_c_0, '0']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_rotator_cc_0, '0', blocks_delay_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [calibrate_bladerf_single_c_0, '0', virtual_sink_0, '0']
- [droneid_msg_trigger_0, pdu, droneid_print_msg_0, in]
- [droneid_msg_trigger_0, pdu, droneid_save_msg_0, in]
- [droneid_msg_trigger_0, pdu, qtgui_time_sink_x_0_0_0, in]
- [droneid_single_trigger_0, pdu, droneid_msg_trigger_0, in]
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-350-gb58667b4
