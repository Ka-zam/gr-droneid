options:
  parameters:
    generate_options: no_gui
    id: msg
    output_language: cpp
    title: small msg test
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.2.0
