options:
  parameters:
    generate_options: no_gui
    id: msg
    output_language: python
    title: small msg test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 15360000*4
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: droneid_bladerf_lb_0
  id: droneid_bladerf_lb
  parameters:
    samp_rate: samp_rate
  states: {}

connections:
- [droneid_bladerf_lb_0, '0', blocks_null_sink_0, '0']
- [droneid_bladerf_lb_0, error, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-350-gb58667b4
