options:
  parameters:
    generate_options: no_gui
    id: msg
    output_language: python
    title: small msg test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 15360000*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: droneid_bladerf_lb_0
  id: droneid_bladerf_lb
  parameters:
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [droneid_bladerf_lb_0, '0', blocks_null_sink_0, '0']
- [droneid_bladerf_lb_0, error, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.2.0
