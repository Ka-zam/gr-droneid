options:
  parameters:
    generate_options: qt_gui
    id: bladeRF_dji_trigger
    output_language: python
    title: bladeRF DJI trigger
  states: {}

blocks:
- name: LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 750e3
    win: window.WIN_HAMMING
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Fc
    start: '500'
    step: '.5'
    stop: '6000'
    value: '2414.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '63'
    value: '60'
  states: {}
- name: lo
  id: variable_qtgui_range
  parameters:
    label: LO
    start: '-2000'
    step: '1'
    stop: '2000'
    value: '-500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15360000*1
  states: {}
- name: trig_level
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: trig_level
  id: variable_qtgui_range
  parameters:
    label: Trig level
    start: '0'
    step: '.1'
    stop: '50'
    value: '10'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 3500*int(samp_rate/15.36e6)
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/magnus/src/drone_id/samples/mv2_2415_1536.fc32
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/magnus/src/drone_id/samples/xam
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: lo*1e3/samp_rate*2*np.pi
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '0'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: calibrate_bladerf_single_c_0
  id: calibrate_bladerf_single_c
  parameters:
    biastee_rx: '0'
    bw: '56000000'
    external_freq: '10000000'
    external_ref: '1'
    freq: int(fc* 1000000)
    gain: gain
    gm: '0'
    samp_rate: samp_rate
    verbose: '0'
  states: {}
- name: droneid_trig_save_0
  id: droneid_trig_save
  parameters:
    filename: droneid_burst_3072
    threshold: trig_level
    zc4: utilities.create_zc_sequence(samp_rate/decimation, 4)
    zc6: utilities.create_zc_sequence(samp_rate/decimation, 6)
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: utilities.create_zc_sequence(samp_rate/decimation)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.droneid import utilities
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      2414.5                       5756.5
      2429.5                       5776.5
      2444.5                       5796.5
      2459.5                       5816.5
      2474.5 (rarely)         5836.5  (rarely)

      FFT length: 1024
    note: Frequency table
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Freq"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    grid: 'True'
    marker1: '7'
    size: '128'
    srate: samp_rate/decimation
    tr_delay: '3e-6'
    tr_level: trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: trig_level + 1
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: in
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: in
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: in
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: in
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [calibrate_bladerf_single_c_0, '0', virtual_sink_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0_1, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
