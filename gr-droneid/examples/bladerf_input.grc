options:
  parameters:
    generate_options: qt_gui
    id: bladeRF_dji_trigger
    output_language: python
    title: bladeRF DJI trigger
  states: {}

blocks:
- name: LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 750e3
    win: window.WIN_HAMMING
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: FC
    rangeType: int
    start: '500'
    step: '10'
    stop: '6000'
    value: '2415'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '63'
    value: '6'
  states: {}
- name: lo
  id: variable_qtgui_range
  parameters:
    label: LO
    start: '-2000'
    step: '1'
    stop: '2000'
    value: '-500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15360000*1
  states: {}
- name: trig_level
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: trig_level
  id: variable_qtgui_range
  parameters:
    label: Trig level
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '3500'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/magnus/src/drone_id/samples/mv2_2415_1536.fc32
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/magnus/src/drone_id/samples/out.fc32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: lo*1e3/samp_rate*2*np.pi
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '0'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: calibrate_bladerf_source_0
  id: calibrate_bladerf_source
  parameters:
    biastee_rx: '0'
    bw: '56000000'
    external_freq: '10000000'
    external_ref: '0'
    freq: fc*1000000
    gain0: gain
    gain1: gain
    gm0: '0'
    gm1: '0'
    samp_rate: samp_rate
    verbose: '0'
  states: {}
- name: droneid_trig_save_0
  id: droneid_trig_save
  parameters:
    chunk_size: '14200'
    filename: droneid_burst
    threshold: trig_level
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: utilities.create_zc_sequence(samp_rate/decimation)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.droneid import utilities
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      2414.5                       5756.5
      2429.5                       5776.5
      2444.5                       5796.5
      2459.5                       5816.5
      2474.5 (rarely)      5836.5  (rarely)

      FFT length: 1024
    note: Frequency table
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Freq"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    grid: 'True'
    marker1: '7'
    size: '128'
    srate: samp_rate/decimation
    tr_delay: '3e-6'
    tr_level: trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: trig_level + 1
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: in
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: in
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', droneid_trig_save_0, '1']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', droneid_trig_save_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [calibrate_bladerf_source_0, '0', virtual_sink_0, '0']
- [calibrate_bladerf_source_0, '1', blocks_null_sink_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_2, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
